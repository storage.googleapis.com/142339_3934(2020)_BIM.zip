Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-06-09T13:26:32
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jun 09 13:26:32 2020 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{3EFBDBE3-6D16-49B8-AF71-EE2A28172B27}\ifc * Database version: 5507 * Database creation date: Tue Jun 09 13:26:31 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jun 09 13:26:31 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jun 09 13:26:31 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 3934 Kitchen faucet with dishwasher valve, 3934(2020):3934 Kitchen faucet with dishwasher valve:341613
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 10 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 3934(2020); ConvergoRefNr: 0087-1803-0056-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for sinks; NBSReference: 45-35-70/345; ProductInformation: Kitchen faucet with swivel spout and aerator; Revision: 1; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Sink manual water supply sets; Uniclass2015Reference: Pr_40_20_87_82; Version: 2; VersionDate: 01/05/2020
Type - Green Building Properties(Type) - Approval KIWA SE Type Approval: 1444; Customs Code: 84818011; EAN Number: 6414150078064; EN Standard: EN 817; URL KIWA SE Type Approval: http://static.oras.com/SETypeApproval/3934
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/3934; Catalog Drawing URL: http://static.oras.com/catdrw/3934; Class: Single lever; Description: Kitchen faucet with swivel spout and aerator; Dimension Drawing URL: http://static.oras.com/dimdrw/3934; FDV Document URL: http://www.oras.com/datasheet/3934/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/3934; Group: Kitchen faucets; Long Marketing: Kitchen faucet with high spout and dishwasher valve with ceramic cartridge 90 ° rotation for ON/OFF. Swivel spout and aerator. Spout's swing angle is factory preset at 120° (can be limited to 60°). There are also in-built limitation options for water temperature and maximum flow-rate.; Manufacturer: Oras; Market: INT;POL;RUS;EST;LTU;LVA;UKR; Model: 3934 Kitchen faucet with dishwasher valve; Name_en: 3934 Kitchen faucet with dishwasher valve; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 696 x 320 x 88; Package Weight: 1.609 kg; Product Code: 3934; Product Datasheet: http://www.oras.com/datasheet/3934/en; Product Family: Oras Saga; Product Image URL: http://static.oras.com/image/3934; Product URL: http://static.oras.com/3934; Type Name: 3934 Kitchen faucet with dishwasher valve; Usage Group: Households
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: Rapid Installation System; Connection: Copper Inlet Pipes; Dishwasher Valve: Dishwasher valve; Flow Rate At 300kPa: 0.00776923 m3/s; Installation and Maintenance: http://static.oras.com/manual/3934; Installation Type: Deck mounted; Lever Handle: Lever with H+C symbol; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: 35Cartridge; Mounting Holes: 1 Mounting Hole; Noise Class: I (ISO 3822); Pressure Loss With Flow 02ls: 300000 Pa; Spare Parts: http://static.oras.com/sp/3934; Spout Swivel Range: 120° (60° / 0°); Spout Type: Swivel spout; Temperature: Temperature limiter
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 3934(2020); Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 3934; Name: 3934 Kitchen faucet with dishwasher valve; ReplacementCost: n/a; Shape: Sculptured; Size: 85x255x300 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 3934; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 3934 Kitchen faucet with dishwasher valve
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.126027 m2; Volume: 0.00666739 m3
Identity Data - Mark: 12
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 3934(2020): 3934 Kitchen faucet with dishwasher valve; Family and Type: 3934(2020): 3934 Kitchen faucet with dishwasher valve; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 3934(2020): 3934 Kitchen faucet with dishwasher valve; Type Id: 3934(2020): 3934 Kitchen faucet with dishwasher valve; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
